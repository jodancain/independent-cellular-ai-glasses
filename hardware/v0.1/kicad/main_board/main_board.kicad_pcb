# Repository jodancain/independent-cellular-ai-glasses

File README.md:

# 独立蜂窝智能眼镜开发需求

**v0.1 公开讨论稿 · 来源核验日期 2026-11-02**

本项目整理可独立联网的智能眼镜需求，供硬件供应商、系统开发者和集成方共同评审。优先面向汽车服务场景中的现场作业与远程协作，并预留面向车主的功能路线。

目标是找到一套**脱离手机和手机热点、使用机内 SIM 或 eSIM 蜂窝网络、由 ARM 应用主处理器运行自研业务软件**的可维护方案。应用、账号和云服务由项目方自主建设，不以第三方消费级品牌的账号、AI 或云服务作为核心功能前提。

本仓库是需求、证据和方案讨论的协作入口，**不是可直接量产的硬件设计，不是性能承诺、采购订单或最终冻结规格**。具体配置、费用、认证、供货与维护责任须另行确认。

## 从哪里开始

| 文档 | 内容 |
| --- | --- |
| [开发需求](docs/requirements.md) | 硬性边界、场景、硬件选项、系统交付和验证方法 |
| [芯片候选](docs/chips.md) | 已讨论平台的公开信息、项目判断及待核实项 |
| [工程判断](docs/engineering-assessment.md) | 选型依据、系统集成风险及证据边界 |
| [串流终端方向](docs/streaming-direction.md) | v0.7.6：眼镜有脑、有小脑、有手、有脚（脚 = 蜂窝 / Wi-Fi 7 / BLE / USB-C 连接，决定 #25）；默认无线、依赖网络而非手机的串流 AR 眼镜；联网全功能 / 断网手表模式、光波导 + 光机、手机级视频通话与虚拟形象、6DoF 真实画面交互、开放云、8 小时混合续航、续航优先、佩戴无感的重量分配、芯片组合 |
| [技术路线](docs/technical-roadmap.md) | 四颗主芯片按角色分工（主 SoC 与显示与重投影处理器是小脑，RedCap 是脚，常驻 BLE 与听音的低功耗 MCU 是常醒的小脑兼管脚的 BLE）各子系统主选 / 备选与切换条件、软件栈与开放协议、M0 验证 → M1 桌面功能样机 → M2 完全版样机 → M3 优化样机 |
| [在线浏览](https://glasses.youngtuo.win/) | 本仓库文档的网页版与动态架构图，公网可直接访问 |
| [系统架构图](docs/system-architecture.md) | 11 张图：系统全景（脑 / 小脑 / 手 / 脚）、硬件框图（两张）、显示数据通路（含看板态）、软件栈、协议通道、功耗状态机、通话与虚拟形象、部署视图、显示模式与小脑调度、投屏与多路信号；动态版见 `visuals/architecture-motion` |
| [设计开发要求](docs/design-requirements.md) | 218 条可验收要求（SYS / HW / PWR / DISP / NET / SW / HOST / PROT / CALL / APP / CLOUD / ERGO / SEC / DEV），每条含来源、优先级、验证方法、阶段，附 25 条决定追溯表与脑 / 小脑 / 手 / 脚角色映射 |
| [原型经验](docs/prototype-learnings.md) | 应用原型里验证过的核心技术：第一视角投屏与专家标注回传、远程视频通话（路线收敛、六档带宽自适应、会议入会）、头姿与相机–IMU 时间对齐、显示–相机标定、采集质量门、Agent 边界与来源标注 |
| [现成硬件验证计划](docs/validation-plan.md) | 自研前用现成设备做的 6 组验证：串流延迟与兼容、6DoF 交互、RedCap 联网与睡眠、手表模式功耗、视频通话与虚拟形象、佩戴无感基线；含设备清单、步骤、通过标准与记录表 |
| [第 1、3、6 组设备准备清单](docs/equipment-groups-1-3-6.md) | 先做的三组验证的候选设备、共用关系与核实项（不含价格） |
| [测试工具](tools/README.md) | 第 1、3、6 组的计时页、延迟统计、RedCap AT / 测速 / 电流分析、人体工学统计脚本（标准库，含单元测试） |
| [供应商回复模板](docs/supplier-response.md) | 可复制的技术方案回复与偏差表 |
| [硬件初版 v0.1](hardware/v0.1/README.md) | 两块板的 KiCad 原理图与初版 PCB（MCU 常驻板全真实器件、已布线、剩 4 处断线；主板主 SoC 等为占位、只有布局），网站 [硬件页](https://glasses.youngtuo.win/hardware.html) 用 three.js 三维查看；还不能下单 |
| [完整来源](docs/sources.md) | 官方资料、公开参考项目及核验日期 |
| [贡献指南](CONTRIBUTING.md) | Issue、Pull Request 和公开资料边界 |

## 当前合作重点

1. 对比 W527、W5 系列蜂窝SKU及供应商已有量产经验的替代方案，不预先锁定单一芯片。
2. 对基础 HUD 文字箭头与空间 AR 分两档提案和报价，不将 6DoF 作为统一硬性要求（本条针对[开发需求](docs/requirements.md)的轻量眼镜；[串流终端方向](docs/streaming-direction.md)需求方已确认需要 6DoF）。
3. 在相同负载下验证整机功耗、温升、续航、音视频、显示和蜂窝并发能力。
4. 确认 BSP、驱动、系统接口、权限、签名、OTA、许可和长期维护能实际交付。

## 如何公开协作

- 对需求、资料或结论有补充，可先开 Issue，说明具体问题、来源和影响。
- 供应商可复制[回复模板](docs/supplier-response.md)，通过 Pull Request 提交可公开的技术方案；也可直接提出文档修订。
- 每次修改应区分公开事实、项目判断、建议目标和待确认项。参数变化须附来源版本、测试条件或明确的待验证说明。
- Pull Request 由维护者评审后决定是否合并。提交建议不代表获得直接写入权限、方案被选用或采购承诺。
- 商业报价、合同、保密资料和个人联系方式不放入公开 Issue 或 PR，另用双方确认的非公开渠道交流。

## 公开内容边界

本仓库只维护可公开的文本需求和引用。不接收固件、SDK 二进制、解包文件、私钥、令牌、真实设备标识、内部日志或客户数据。不要上传本方内部需求文件的原始副本。

## 许可状态

本项目暂未选择仓库许可证。不要把公开可读或接受 PR 理解为已授予 MIT、Apache 或其他开源许可。引用的第三方项目和资料分别遵循其自身许可与使用条件；本仓库不改变这些条件。

## KiCad design hardware/v0.1/kicad/main_board/main_board.kicad_pcb

File hardware/v0.1/README.md:

# 初版原理图与 PCB v0.1（2026-11-05）

**一句话**：两块板的 KiCad 原理图与 PCB 已生成，能在网站的 [硬件页](https://glasses.youngtuo.win/hardware.html) 用 three.js 看（原理图可无限缩放、可搜网络；PCB 是三维的；还有装进眼镜的示意）。**MCU 常驻板已布线，只剩 4 处断线待人工补（0 短路、0 间距问题）；主板仍只有布局，2026-11-09 已把 RedCap 模组 RG255C-GL 换成真实引脚和焊盘，剩 12 个占位。两块都还不能直接下单。**

## 目录

| 位置 | 内容 |
| --- | --- |
| `viewer/` | three.js 展示页（three.js 0.180 已内置）。本地看：在该目录运行 `python3 -m http.server`，打开 http://localhost:8000 |
| `kicad/mcu_board/`、`kicad/main_board/` | KiCad 10 工程：原理图、PCB、项目自建符号库与封装库 |
| `exports/<板>/` | 原理图 PDF、渲染图、ERC / DRC 报告（三维 GLB 在 `viewer/data/`）；`exports/kicad-projects-v0.1.zip` 为两个 KiCad 工程打包 |
| `exports/<板>/jlcpcb/` | 嘉立创格式：Gerber 压缩包、钻孔、`BOM_JLCPCB.csv`、`CPL_JLCPCB.csv`（坐标） |
| `generator/` | 生成脚本。需要 KiCad 10，并从 ST 的 [STM32_open_pin_data](https://github.com/STMicroelectronics/STM32_open_pin_data) 下载 `mcu/STM32N657X0HxQ.xml` 放进本目录（本仓库不转载 ST 原始文件）；改 `design.py` 后运行 `./build_all.sh <输出目录>` 一键重建 |

## 两块板

| 板 | 形态 | 层数 | 器件 / 网络 | 说明 |
| --- | --- | --- | --- | --- |
| **MCU 常驻板** | 右镜腿形 78×16 mm，双面贴装 | 6 层 | 84 / 95 | **全部真实器件**：STM32N657（MCU A 案）、nRF52832（常驻 BLE）、APS6404L PSRAM、W25Q128JW NOR、2 颗 PDM 麦克风、MAX98357A 功放、BQ24075 充电、TPS62823 1.8 V、佩戴检测、SWD |
| **主板** | M1 桌面载板 100×70 mm | 8 层 HDI | 77 / 222 | 主 SoC、Wi-Fi 7、PMIC、LT7911UXC（已定封装与供电、球位待定）、FPGA、Type-C 复用 / PD、显示与摄像头开关、SIM 卡座、eSIM **共 12 个占位**；**RG255C-GL 已是真实引脚与 LGA-204 焊盘**；USB-C、IMU、充电、FPC / 板间连接器、天线座为真实器件 |

两板之间用 Hirose DF40 40 针板对板连接器，引脚定义两边共用（见下表）。

## MCU 常驻板布线（2026-11-05）

- **工具**：Freerouting 2.5（开源自动布线器），由 `generator/route.py` 调用；KiCad 10 导出 / 导入 Specctra。
- **叠层**：6 层。F.Cu 信号 / In1 地平面 / In2 信号 / In3 1.8 V 平面 / In4 信号 / B.Cu 信号；顶层、底层铺地。
- **规则**：信号线 0.1 mm（Freerouting 在细间距处收窄的线统一加宽到 0.09 mm），电源线 0.25 mm，间距 0.09–0.1 mm，过孔 0.3 / 0.15 mm，板边 0.25 mm——按嘉立创多层板能力设定。
- **做法**：先扇出（地和 1.8 V 焊盘就近打孔到平面，BGA 与散热焊盘用盘中孔），再三遍自动布线；Freerouting 卡住的断线再用自写的网格迷宫布线器（`maze.py`，A* 寻路，四个信号层可换层打孔，保持 0.1 mm 间距与 0.2 mm 孔距）补；最后按 DRC 清掉悬空过孔和多余短线。
- **结果**：约 2000 段走线、约 350 个过孔；**0 短路、0 间距、0 线宽 / 板边问题**。迷宫布线器补上了核心 0.8 V、降压反馈、按键、系统电源、麦克风地各一处。还剩 **4 处断线**（C17、R15、C45 三个 1.8 V 焊盘和 U1 的 R4 球位 0.8 V，都在底面器件密集处，可能要挪一两个电阻电容）、1 段悬空短线、3 条铺地连通提示（需在 KiCad 里打开确认）和 11 处散热焊盘连接筋偏少的提醒，需要人工处理。
- **盘中孔**：STM32N657 的 0.8 mm BGA 在 16 mm 高的板上必须用盘中孔，下单时要选“盘中孔（树脂塞孔 + 电镀盖帽）”工艺。
- 重新布线：`<KiCad python> generator/route.py kicad/mcu_board <java25> <freerouting.jar> 60`，再用 `drc_cleanup.py` 按 DRC 报告清理。

## 按角色看两块板（方案 §1.1：脑、小脑、手、脚）

| 角色 | MCU 常驻板（右镜腿） | 主板（左镜腿，暂为桌面载板） |
| --- | --- | --- |
| **脑** | 唤醒词入口（MCU 常驻听音） | 意图入口与派手路由跑在主 SoC 上；推理在云端 LLM，没有单独芯片 |
| **小脑** | STM32N657、PSRAM、NOR、佩戴检测（常醒的那部分小脑） | 主 SoC（占位）、显示与重投影 FPGA（占位）、IMU、显示开关 |
| **脚** | nRF52832 + 片状天线：BLE 常连，主 SoC 睡着也能收气泡 | RedCap 模组 + SIM / eSIM + 两路蜂窝天线、Wi-Fi 7 + 天线、USB-C（A1 DP / A2 USB 3）、DP 接收桥 |
| **手** | 不在眼镜上 | 不在眼镜上（手机、电脑、车机、云主机） |
| **器官** | 麦克风 ×2（嘴巴）、扬声器功放（耳朵） | 主摄与追踪相机（眼睛）、两路光机排线（视网膜） |
| **身体** | 右侧电池、充电、1.8 V 电源 | 左侧电池、充电、SoC 电源（占位） |

每个器件的角色写在 `kicad/<板>/<板>.netlist.json` 的 `role` 字段，查看页“按角色”一栏也按这个分组。

## 投屏与多路信号在板上的落点（方案 §3.11、§4.5）

- **显示处理器（主板 U6，FPGA 占位）**：两路 MIPI 输入（主 SoC 合成画面、LT7911UXC 的 DP 画面）+ 一路来自 MCU 的低速叠加层输入（`DISP_LS_*`，经板间连接器），用来在 A1 有线、主 SoC 睡着时把气泡叠加到 DP 画面上（设计开发要求 HW-DP-07）。
- **主摄**：经 MIPI 二选一开关给主 SoC 或 MCU；主 SoC 端一次采集分给取景、识别、通话编码（SW-22）。
- **麦克风**：直连 MCU 常驻听音，同时经板间连接器把 PDM 送给主 SoC 做混音与回声消除（HW-AUD-04）。
- **并发能力**：能同时硬解几路取决于主 SoC，属于门禁 HW-SOC-07，等芯片资料，板上不体现。

## 引脚从哪来

- **STM32N657X0H3Q**：264 个球位全部来自 ST 官方 `STM32_open_pin_data`；外设复用功能（XSPI、USART、SPI、MDF、SAI、I2C、ADC）由脚本按 ST 数据自动分配，保证与芯片一致。封装按 VFBGA264、球距 0.8 mm 生成，**须对照 ST 封装图核实焊盘尺寸**。
- **其余真实器件**：KiCad 10 官方库的符号与封装。
- **RG255C-GL（2026-11-09 去占位）**：204 个引脚名与 LGA-204（32×29 mm）焊盘来自立创 EDA 公开库 C22437156（easyeda2kicad 转换，存于 `generator/vendor/`）。已接：VBAT_BB / VBAT_RF、GND、PCIe（TX/RX/REFCLK/PERST/CLKREQ/PEWAKE）、USIM1、PWRKEY、RESET_N、STATUS、W_DISABLE、主 / 分集天线；其余引脚标不连接。PWRKEY / RESET_N 由主 SoC GPIO 经 Q1 / Q2（NPN 开集，4.7k / 47k）驱动；USB_BOOT、调试串口、USB 引到 TP1–TP6；方案不含 GNSS，ANT_GNSS 悬空。**下单前要对照移远《RG255C-GL 硬件设计手册》逐脚核对，驱动阻值也按手册核对。**
- **LT7911UXC（2026-11-09 部分更新）**：按龙迅公开产品简介（R1.0）改为 BGA169 9×9 mm、3.3 V + 1.1 V 供电（新增 U19 TPS62823 降压到 1.1 V，L2 / R3 / R4 / C52–C54）、外部 25 MHz 晶振（Y1，负载电容 C50 / C51 待按晶振规格调）；芯片内置双 CC 与 PD 控制器，U12 PD 控制器有望省掉（待定）。产品简介没有球位表，**球位编号仍是占位**，要向龙迅要完整规格书。
- **其余占位器件**：只列功能引脚，编号是临时的。AR2 Gen 1 要和高通签 NDA；FPGA 与开关等 M1 选型后补。

## 检查结果

| 板 | ERC | DRC 硬错误（间距 / 短路 / 重叠） | 其余 DRC | 未布线焊盘 |
| --- | --- | --- | --- | --- |
| MCU 常驻板 | 2 条（两颗 PDM 麦克风共用数据线、功放散热焊盘接地，均属正常） | 0 | 丝印重叠等外观项；地平面与麦克风 / SWD 定位孔的间距 | 335 |
| 主板 | 2 条（WEAR_DET 只经板间连接器；IMU 辅助口接地） | 0 | 丝印外观项；USB-C 贴板边（按设计） | 499（RG255C 换真实焊盘后地脚变多） |

设计规则按嘉立创多层板能力设为线宽 / 间距 0.09–0.1 mm、过孔 0.3 / 0.15 mm。

## 交给嘉立创之前还差什么

1. **布线**：MCU 常驻板剩 4 处断线在 KiCad 里人工补完并复查 DRC；主板要等占位器件换成真实引脚和封装。
2. **补全器件资料**：去耦电容按各芯片手册补齐；BOM 的 `LCSC` 一列填立创商城编号（RG255C-GL 在嘉立创元件库为 C22437156、LT7911UXC 在立创商城为 C5310989，均无现货）；高通、移远、龙迅等器件走客供料。
3. **工艺确认**：STM32N657 的 0.8 mm BGA、DF40 0.4 mm 连接器，需要 HDI / 盲埋孔报价；眼镜形态的软硬结合板要单独询价。
4. **再跑一次 DRC、出 Gerber**，用嘉立创的 DFM 检查后下单。

## MCU 引脚分配（脚本按 ST 数据生成）

| 网络 | STM32N657 引脚 | 球位 | 功能 |
| --- | --- | --- | --- |
| AMP_SD_MODE | PA7 | R12 | GPIO |
| BLE_IRQ | PA4 | U14 | GPIO |
| BLE_RESET_N | PA5 | R8 | GPIO |
| BLE_UART_CTS | PF3 | M2 | USART2_RTS |
| BLE_UART_RTS | PG5 | M4 | USART2_CTS |
| BLE_UART_RX | PD5 | D14 | USART2_TX |
| BLE_UART_TX | PC2 | D9 | USART2_RX |
| BTN_PWR | PB1 | R11 | GPIO |
| CAM_SEL | PA12 | U7 | GPIO |
| CELL_PWR_EN | PA2 | T8 | GPIO |
| CHG_PGOOD_N | PA8 | U8 | GPIO |
| CHG_STAT_N | PA9 | P7 | GPIO |
| DISP_LS_CS | PA1 | P9 | GPIO |
| DISP_LS_DC | PA10 | R7 | GPIO |
| DISP_LS_MOSI | PG14 | P6 | SPI6_MOSI |
| DISP_LS_SCK | PC12 | C8 | SPI6_SCK |
| DISP_SEL | PA11 | T7 | GPIO |
| FLASH_CLK | PN6 | P15 | XSPIM_P2_CLK |
| FLASH_CS | PN1 | R17 | XSPIM_P2_NCS1 |
| FLASH_IO0 | PN2 | T17 | XSPIM_P2_IO0 |
| FLASH_IO1 | PN3 | R15 | XSPIM_P2_IO1 |
| FLASH_IO2 | PN4 | N17 | XSPIM_P2_IO2 |
| FLASH_IO3 | PN5 | R16 | XSPIM_P2_IO3 |
| I2C_PWR_SCL | PE5 | C11 | I2C1_SCL |
| I2C_PWR_SDA | PC1 | A9 | I2C1_SDA |
| I2S_BCLK | PB6 | E17 | SAI1_SCK_A |
| I2S_DOUT | PD2 | C12 | SAI1_SD_A |
| I2S_LRCLK | PB0 | E15 | SAI1_FS_A |
| LED_STAT | PB10 | U11 | GPIO |
| MCU_IRQ_TO_SOC | PG0 | R13 | GPIO |
| MIC_PDM_CLK | PE2 | F15 | MDF1_CCK0 |
| MIC_PDM_DAT | PE8 | A15 | MDF1_SDI0 |
| PSRAM_CLK | PO4 | N16 | XSPIM_P1_CLK |
| PSRAM_CS | PO0 | M17 | XSPIM_P1_NCS1 |
| PSRAM_IO0 | PP0 | G17 | XSPIM_P1_IO0 |
| PSRAM_IO1 | PP1 | H16 | XSPIM_P1_IO1 |
| PSRAM_IO2 | PP2 | J17 | XSPIM_P1_IO2 |
| PSRAM_IO3 | PP3 | J16 | XSPIM_P1_IO3 |
| SOC_PWR_EN | PG11 | U13 | GPIO |
| SOC_RESET_N | PG10 | T10 | GPIO |
| SOC_SPI_CS | PH6 | B2 | SPI5_NSS |
| SOC_SPI_MISO | PD4 | B15 | SPI5_MISO |
| SOC_SPI_MOSI | PH7 | D2 | SPI5_MOSI |
| SOC_SPI_SCK | PE15 | A12 | SPI5_SCK |
| SOC_WAKE_REQ | PG1 | R9 | GPIO |
| VBAT_SENSE | PA0 | U10 | ADC1_INP0 |
| WEAR_DET | PA6 | P8 | GPIO |
| WIFI_PWR_EN | PA3 | R14 | GPIO |

## 板间连接器 J1 / J2（DF40 40 针）

| 针 | 网络 |
| --- | --- |
| 1 | VBUS |
| 2 | VBUS |
| 3 | GND |
| 4 | GND |
| 5 | +1V8_AON |
| 6 | GND |
| 7 | SOC_SPI_SCK |
| 8 | SOC_SPI_MISO |
| 9 | SOC_SPI_MOSI |
| 10 | SOC_SPI_CS |
| 11 | MCU_IRQ_TO_SOC |
| 12 | SOC_WAKE_REQ |
| 13 | SOC_RESET_N |
| 14 | SOC_PWR_EN |
| 15 | CELL_PWR_EN |
| 16 | WIFI_PWR_EN |
| 17 | DISP_SEL |
| 18 | CAM_SEL |
| 19 | GND |
| 20 | DISP_LS_SCK |
| 21 | DISP_LS_MOSI |
| 22 | DISP_LS_CS |
| 23 | DISP_LS_DC |
| 24 | GND |
| 25 | CAM_MCU_CKP |
| 26 | CAM_MCU_CKN |
| 27 | GND |
| 28 | CAM_MCU_D0P |
| 29 | CAM_MCU_D0N |
| 30 | GND |
| 31 | CAM_MCU_D1P |
| 32 | CAM_MCU_D1N |
| 33 | GND |
| 34 | I2C_PWR_SCL |
| 35 | I2C_PWR_SDA |
| 36 | WEAR_DET |
| 37 | MIC_PDM_CLK |
| 38 | MIC_PDM_DAT |
| 39 | GND |
| 40 | GND |

## 已知的初版假设（须核实）

- STM32N6 电源脚：VDDCORE / VDDCSI 接内部 SMPS 输出 0.8 V，其余 VDD* 接 1.8 V；VDD33USB 未用 USB，暂接 1.8 V。
- 佩戴检测 APDS-9160 用 3.3 V 供电、I2C 上拉到 1.8 V，电平兼容待核。
- 手表模式录制存储方案写的是小容量 NAND，初版先放 NOR，待定。
- 主板 RedCap 电源暂用 0 Ω 直连，后续换负载开关。

Schematic: main_board.kicad_sch, 主板（小脑：主 SoC + 显示处理器；脚：RedCap + Wi-Fi 7 + USB-C）

Parts:
C1: 22uF; C_0402_1005Metric
C2, C6, C40: 1uF; C_0402_1005Metric
C3, C4, C5, C21, C30, C41, C52: 10uF; C_0402_1005Metric
C20: 100uF; C_0603_1608Metric
C22, C31, C32, C35, C53, C54: 100nF; C_0201_0603Metric
C42: 4.7uF; C_0402_1005Metric
C43: 1uF; C_0201_0603Metric
C50, C51: 12pF; C_0201_0603Metric
J1: USB-C（DP Alt / USB 3 / PD）; USB_C_Receptacle_Amphenol_12401610E4-2A
J2: 板间 DF40 40P（至 MCU 板）; Hirose_DF40C-40DS-0.4V_2x20_P0.4mm
J3: 追踪相机 L; Hirose_FH26-15S-0.3SHW_2Rows-15Pins-1MP_P0.60mm_Horizontal
J4: 追踪相机 R; Hirose_FH26-15S-0.3SHW_2Rows-15Pins-1MP_P0.60mm_Horizontal
J5: 主摄（1080p30 起）; Hirose_FH26-15S-0.3SHW_2Rows-15Pins-1MP_P0.60mm_Horizontal
J6: 眼动相机（预留）; Hirose_FH26-15S-0.3SHW_2Rows-15Pins-1MP_P0.60mm_Horizontal; not fitted
J7: 光机 L（光波导）; Hirose_FH26-25S-0.3SHW_2Rows-25Pins-1MP_P0.60mm_Horizontal
J8: 光机 R（光波导）; Hirose_FH26-25S-0.3SHW_2Rows-25Pins-1MP_P0.60mm_Horizontal
J9: Wi-Fi 天线; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J10: 蜂窝主天线; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J11: 蜂窝分集天线; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J12: Nano SIM 卡座（M2 期间保留）; PH_NANO_SIM_HOLDER
J13: 左侧电池; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
L1, L2: 0.47uH; L_0805_2012Metric
Q1, Q2: MMBT3904; SOT-23
R1, R3: 100k; R_0201_0603Metric
R2: 150k; R_0201_0603Metric
R4: 120k; R_0201_0603Metric
R10: 1.13k; R_0201_0603Metric
R11: 3.0k; R_0201_0603Metric
R12: 46.4k; R_0201_0603Metric
R20: 0; R_0603_1608Metric
R21, R23: 4.7k; R_0201_0603Metric
R22, R24: 47k; R_0201_0603Metric
TP1: CELL_USB_BOOT; TestPoint_Pad_D1.0mm
TP2: CELL_DBG_TX; TestPoint_Pad_D1.0mm
TP3: CELL_DBG_RX; TestPoint_Pad_D1.0mm
TP4: CELL_USB_DP; TestPoint_Pad_D1.0mm
TP5: CELL_USB_DM; TestPoint_Pad_D1.0mm
TP6: CELL_USB_VBUS; TestPoint_Pad_D1.0mm
U1: Snapdragon AR2 Gen 1（占位）; PH_SOC_AR2_GEN1_PLACEHOLDER
U2: SoC 配套 PMIC（占位）; PH_PMIC_SOC_PLACEHOLDER
U3: Wi-Fi 7 + 蓝牙连接芯片（占位）; PH_WIFI7_COMBO_PLACEHOLDER
U4: Quectel RG255C-GL（X35 RedCap）; Quectel_RG255C-GL_LGA-204_32x29mm
U5: eSIM（MFF2，占位）; PH_ESIM_MFF2; not fitted
U6: 显示与重投影处理器（原型 FPGA，占位）; PH_DPU_FPGA_PLACEHOLDER
U7: FPGA 配置 Flash; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
U8: TPS62823 DPU 内核; Texas_VSON-HR-8_1.5x2mm_P0.5mm
U9: LSM6DSM 6 轴 IMU（≥1 kHz）; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U10: LT7911UXC DP→MIPI（BGA169 9×9，球位待定）; PH_LT7911UXC_BGA169_PLACEHOLDER
U11: Type-C DP/USB3 复用开关（占位）; PH_TYPEC_DP_USB_MUX_PLACEHOLDER
U12: USB PD + DP Alt 控制器（占位）; PH_PD_CONTROLLER_PLACEHOLDER
U13: ESD; USON-10_2.5x1.0mm_P0.5mm
U14: BQ24075 左侧; VQFN-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm
U15: TLV75533 3.3V 射频; SOT-23-5
U16: 主摄 MIPI 二选一（占位）; PH_MIPI_SWITCH_CAM_PLACEHOLDER
U17: 显示开关 L（占位）; PH_DISP_SWITCH_L_PLACEHOLDER
U18: 显示开关 R（占位）; PH_DISP_SWITCH_R_PLACEHOLDER
U19: TPS62823 LT7911UXC 1.1V; Texas_VSON-HR-8_1.5x2mm_P0.5mm
Y1: 25MHz ±50ppm; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+1V8_AON: J2.5, U14.5 (EN2)
+1V8_IO: C5.1, C6.1, C35.1, J3.13, J3.14, J4.13, J4.14, J5.13, J5.14, J6.13, J6.14, J7.16, J7.17, J8.16, J8.17, U1.3 (VDD_IO_1V8), U2.10 (VREG_IO), U3.2 (VDD_1V8), U6.2 (VCCIO_1V8), U7.8 (VCC), U9.5 (VDDIO), U9.8 (VDD), U11.1 (VCC), U12.2 (VDD), U16.1 (VCC), U17.1 (VCC), U18.1 (VCC)
+3V3_RF: C43.1, C54.1, U3.1 (VDD_3V3), U10.2 (VDD_3V3), U15.5 (OUT)
ANT_CELL_DIV: J11.1 (In), U4.39 (ANT_DRX)
ANT_CELL_MAIN: J10.1 (In), U4.55 (ANT_MAIN)
ANT_WIFI: J9.1 (In), U3.19 (ANT_WIFI)
BATL_NTC: J13.2, U14.1 (TS)
BT_UART_RX: U1.85 (BT_UART_RX), U3.16 (BT_TX)
BT_UART_TX: U1.84 (BT_UART_TX), U3.17 (BT_RX)
CAM_CKN: J5.8, U16.8 (IN_CKN)
CAM_CKP: J5.9, U16.5 (IN_CKP)
CAM_D0N: J5.2, U16.14 (IN_D0N)
CAM_D0P: J5.3, U16.11 (IN_D0P)
CAM_D1N: J5.5, U16.20 (IN_D1N)
CAM_D1P: J5.6, U16.17 (IN_D1P)
CAM_MCU_CKN: J2.26, U16.10 (B_CKN)
CAM_MCU_CKP: J2.25, U16.7 (B_CKP)
CAM_MCU_D0N: J2.29, U16.16 (B_D0N)
CAM_MCU_D0P: J2.28, U16.13 (B_D0P)
CAM_MCU_D1N: J2.32, U16.22 (B_D1N)
CAM_MCU_D1P: J2.31, U16.19 (B_D1P)
CAM_SEL: J2.18, U16.4 (SEL)
CAM_SOC_CKN: U1.32 (CSI2_CKN), U16.9 (A_CKN)
CAM_SOC_CKP: U1.31 (CSI2_CKP), U16.6 (A_CKP)
CAM_SOC_D0N: U1.34 (CSI2_D0N), U16.15 (A_D0N)
CAM_SOC_D0P: U1.33 (CSI2_D0P), U16.12 (A_D0P)
CAM_SOC_D1N: U1.36 (CSI2_D1N), U16.21 (A_D1N)
CAM_SOC_D1P: U1.35 (CSI2_D1P), U16.18 (A_D1P)
CC1: J1.A5 (CC1), U12.5 (CC1), U13.4 (D2+)
CC2: J1.B5 (CC2), U12.6 (CC2), U13.5 (D2-)
CELL_CLKREQ_N: U1.50 (PCIE0_CLKREQ_N), U4.21 (~CLKREQ)
CELL_DBG_RX: TP3.1, U4.13 (DBG_RXD)
CELL_DBG_TX: TP2.1, U4.14 (DBG_TXD)
CELL_PCIE_CKN: U1.48 (PCIE0_REFCLKN), U4.107 (PCIE_REFCLK_M)
CELL_PCIE_CKP: U1.47 (PCIE0_REFCLKP), U4.105 (PCIE_REFCLK_P)
CELL_PCIE_RXN: U1.46 (PCIE0_RXN), U4.104 (PCIE_TX_M)
CELL_PCIE_RXP: U1.45 (PCIE0_RXP), U4.103 (PCIE_TX_P)
CELL_PCIE_TXN: U1.44 (PCIE0_TXN), U4.102 (PCIE_RX_M)
CELL_PCIE_TXP: U1.43 (PCIE0_TXP), U4.101 (PCIE_RX_P)
CELL_PERST_N: U1.49 (PCIE0_PERST_N), U4.20 (~PERST)
CELL_PWRKEY: R21.1, U1.89 (CELL_PWRKEY)
CELL_PWRKEY_OD: Q1.3 (C), U4.25 (PWRKEY)
CELL_PWR_EN: J2.15, U4.4 (~W_DISABLE)
CELL_RESET_N: R23.1, U1.90 (CELL_RESET_N)
CELL_RESET_OD: Q2.3 (C), U4.24 (RESET_N)
CELL_STATUS: U1.91 (CELL_STATUS), U4.67 (STATUS)
CELL_USB_BOOT: TP1.1, U4.22 (USB_BOOT)
CELL_USB_DM: TP5.1, U4.76 (USB_DM)
CELL_USB_DP: TP4.1, U4.75 (USB_DP)
CELL_USB_VBUS: TP6.1, U4.77 (USB_VBUS)
CELL_WAKE_N: U1.51 (PCIE0_WAKE_N), U4.100 (~PEWAKE)
CHGL_ILIM: R10.1, U14.12 (ILIM)
CHGL_ISET: R11.1, U14.16 (ISET)
CHGL_TMR: R12.1, U14.14 (TMR)
C_RX1N: J1.B10 (RX1-), U11.7 (C_RX1N)
C_RX1P: J1.B11 (RX1+), U11.6 (C_RX1P)
C_RX2N: J1.A10 (RX2-), U11.11 (C_RX2N)
C_RX2P: J1.A11 (RX2+), U11.10 (C_RX2P)
C_TX1N: J1.A3 (TX1-), U11.5 (C_TX1N)
C_TX1P: J1.A2 (TX1+), U11.4 (C_TX1P)
C_TX2N: J1.B3 (TX2-), U11.9 (C_TX2N)
C_TX2P: J1.B2 (TX2+), U11.8 (C_TX2P)
DISPL_CKN: J7.8, U17.8 (OUT_CKN)
DISPL_CKP: J7.9, U17.6 (OUT_CKP)
DISPL_D0N: J7.2, U17.12 (OUT_D0N)
DISPL_D0P: J7.3, U17.10 (OUT_D0P)
DISPL_D1N: J7.5, U17.16 (OUT_D1N)
DISPL_D1P: J7.6, U17.14 (OUT_D1P)
DISPL_LS_CS: J7.13, U17.23 (OUT_CS)
DISPL_LS_DC: J7.14, U17.24 (OUT_DC)
DISPL_LS_MOSI: J7.12, U17.22 (OUT_MOSI)
DISPL_LS_SCK: J7.11, U17.21 (OUT_SCK)
DISPR_CKN: J8.8, U18.8 (OUT_CKN)
DISPR_CKP: J8.9, U18.6 (OUT_CKP)
DISPR_D0N: J8.2, U18.12 (OUT_D0N)
DISPR_D0P: J8.3, U18.10 (OUT_D0P)
DISPR_D1N: J8.5, U18.16 (OUT_D1N)
DISPR_D1P: J8.6, U18.14 (OUT_D1P)
DISPR_LS_CS: J8.13, U18.23 (OUT_CS)
DISPR_LS_DC: J8.14, U18.24 (OUT_DC)
DISPR_LS_MOSI: J8.12, U18.22 (OUT_MOSI)
DISPR_LS_SCK: J8.11, U18.21 (OUT_SCK)
DISP_LS_CS: J2.22, U6.50 (OVL_CS), U17.19 (B_CS), U18.19 (B_CS)
DISP_LS_DC: J2.23, U6.51 (OVL_DC), U17.20 (B_DC), U18.20 (B_DC)
DISP_LS_MOSI: J2.21, U6.49 (OVL_MOSI), U17.18 (B_MOSI), U18.18 (B_MOSI)
DISP_LS_SCK: J2.20, U6.48 (OVL_SCK), U17.17 (B_SCK), U18.17 (B_SCK)
DISP_SEL: J2.17, U17.4 (SEL), U18.4 (SEL)
DPU_CFG_CS: U6.56 (CFG_CS), U7.1 (~CS)
DPU_CFG_IO0: U6.54 (CFG_SO), U7.5 (DI/IO0)
DPU_CFG_IO1: U6.55 (CFG_SI), U7.2 (DO/IO1)
DPU_CFG_SCK: U6.53 (CFG_SCK), U7.6 (CLK)
DPU_FB: R1.2, R2.1, U8.2 (FB)
DPU_L_CKN: U6.28 (TXL_CKN), U17.7 (A_CKN)
DPU_L_CKP: U6.27 (TXL_CKP), U17.5 (A_CKP)
DPU_L_D0N: U6.30 (TXL_D0N), U17.11 (A_D0N)
DPU_L_D0P: U6.29 (TXL_D0P), U17.9 (A_D0P)
DPU_L_D1N: U6.32 (TXL_D1N), U17.15 (A_D1N)
DPU_L_D1P: U6.31 (TXL_D1P), U17.13 (A_D1P)
DPU_RST_N: U1.88 (DPU_RST_N), U6.52 (RESET_N)
DPU_R_CKN: U6.34 (TXR_CKN), U18.7 (A_CKN)
DPU_R_CKP: U6.33 (TXR_CKP), U18.5 (A_CKP)
DPU_R_D0N: U6.36 (TXR_D0N), U18.11 (A_D0N)
DPU_R_D0P: U6.35 (TXR_D0P), U18.9 (A_D0P)
DPU_R_D1N: U6.38 (TXR_D1N), U18.15 (A_D1N)
DPU_R_D1P: U6.37 (TXR_D1P), U18.13 (A_D1P)
DPU_SPI_CS: U1.78 (SPI_DPU_CS), U6.42 (SPI_CS)
DPU_SPI_MISO: U1.77 (SPI_DPU_MISO), U6.41 (SPI_MISO)
DPU_SPI_MOSI: U1.76 (SPI_DPU_MOSI), U6.40 (SPI_MOSI)
DPU_SPI_SCK: U1.75 (SPI_DPU_SCK), U6.39 (SPI_SCK)
DPU_SW: L1.1, U8.6 (SW)
DP_AUXN: U10.17 (DP_AUXN), U11.23 (AUXN)
DP_AUXP: U10.16 (DP_AUXP), U11.22 (AUXP)
DP_HPD: U10.18 (DP_HPD), U11.29 (HPD)
DP_ML0N: U10.9 (DP_ML0N), U11.15 (DP0N)
DP_ML0P: U10.8 (DP_ML0P), U11.14 (DP0P)
DP_ML1N: U10.11 (DP_ML1N), U11.17 (DP1N)
DP_ML1P: U10.10 (DP_ML1P), U11.16 (DP1P)
DP_ML2N: U10.13 (DP_ML2N), U11.19 (DP2N)
DP_ML2P: U10.12 (DP_ML2P), U11.18 (DP2P)
DP_ML3N: U10.15 (DP_ML3N), U11.21 (DP3N)
DP_ML3P: U10.14 (DP_ML3P), U11.20 (DP3P)
EYE_CKN: J6.8, U1.38 (CSI3_CKN)
EYE_CKP: J6.9, U1.37 (CSI3_CKP)
EYE_D0N: J6.2, U1.40 (CSI3_D0N)
EYE_D0P: J6.3, U1.39 (CSI3_D0P)
EYE_D1N: J6.5, U1.42 (CSI3_D1N)
EYE_D1P: J6.6, U1.41 (CSI3_D1P)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C20.2, C21.2, C22.2, C30.2, C31.2, C32.2, C35.2, C40.2, C41.2, C42.2, C43.2, C50.2, C51.2, C52.2, C53.2, C54.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3, J2.4, J2.6, J2.19, J2.24, J2.27, J2.30, J2.33, J2.39, J2.40, J3.1, J3.4, J3.7, J3.10, J3.15, J4.1, J4.4, J4.7, J4.10, J4.15, J5.1, J5.4, J5.7, J5.10, J5.15, J6.1, J6.4, J6.7, J6.10, J6.15, J7.1, J7.4, J7.7, J7.10, J7.15, J7.20, J7.21, J7.24, J7.25, J8.1, J8.4, J8.7, J8.10, J8.15, J8.20, J8.21, J8.24, J8.25, J9.2 (Ext), J10.2 (Ext), J11.2 (Ext), J12.6 (GND), J13.3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
I2C_PWR_SCL: J2.34, U2.11 (SCL), U12.7 (SCL)
I2C_PWR_SDA: J2.35, U2.12 (SDA), U12.8 (SDA)
I2C_SNS_SCL: J3.11, J4.11, J5.11, J6.11, J7.22, J8.22, U1.79 (I2C_SNS_SCL), U10.29 (I2C_SCL)
I2C_SNS_SDA: J3.12, J4.12, J5.12, J6.12, J7.23, J8.23, U1.80 (I2C_SNS_SDA), U10.30 (I2C_SDA)
IMU_CS: U6.46 (IMU_CS), U9.12 (CS)
IMU_INT1: U1.81 (IMU_INT), U6.47 (IMU_INT), U9.4 (INT1)
IMU_MISO: U6.45 (IMU_MISO), U9.1 (SDO/SA0)
IMU_MOSI: U6.44 (IMU_MOSI), U9.14 (SDA)
IMU_SCK: U6.43 (IMU_SCK), U9.13 (SCL)
LT_FB: R3.2, R4.1, U19.2 (FB)
LT_MIPI_CKN: U6.18 (RXB_CKN), U10.20 (MIPI_CKN)
LT_MIPI_CKP: U6.17 (RXB_CKP), U10.19 (MIPI_CKP)
LT_MIPI_D0N: U6.20 (RXB_D0N), U10.22 (MIPI_D0N)
LT_MIPI_D0P: U6.19 (RXB_D0P), U10.21 (MIPI_D0P)
LT_MIPI_D1N: U6.22 (RXB_D1N), U10.24 (MIPI_D1N)
LT_MIPI_D1P: U6.21 (RXB_D1P), U10.23 (MIPI_D1P)
LT_MIPI_D2N: U6.24 (RXB_D2N), U10.26 (MIPI_D2N)
LT_MIPI_D2P: U6.23 (RXB_D2P), U10.25 (MIPI_D2P)
LT_MIPI_D3N: U6.26 (RXB_D3N), U10.28 (MIPI_D3N)
LT_MIPI_D3P: U6.25 (RXB_D3P), U10.27 (MIPI_D3P)
LT_RST_N: U1.87 (LT_RST_N), U10.31 (RST_N)
LT_SW: L2.1, U19.6 (SW)
LT_XI: C50.1, U10.6 (XTAL_IN), Y1.1
LT_XO: C51.1, U10.7 (XTAL_OUT), Y1.3
MCU_IRQ_TO_SOC: J2.11, U1.71 (GPIO_MCU_IRQ)
MIC_PDM_CLK: J2.37, U1.82 (PDM_CLK)
MIC_PDM_DAT: J2.38, U1.83 (PDM_DAT)
PD_INT_N: U1.93 (PD_INT_N), U12.9 (INT_N)
Q1_B: Q1.1 (B), R21.2, R22.1
Q2_B: Q2.1 (B), R23.2, R24.1
SBU1: J1.A8 (SBU1), U11.12 (SBU1)
SBU2: J1.B8 (SBU2), U11.13 (SBU2)
SOC_DSI_CKN: U1.10 (DSI0_CKN), U6.8 (RXA_CKN)
SOC_DSI_CKP: U1.9 (DSI0_CKP), U6.7 (RXA_CKP)
SOC_DSI_D0N: U1.12 (DSI0_D0N), U6.10 (RXA_D0N)
SOC_DSI_D0P: U1.11 (DSI0_D0P), U6.9 (RXA_D0P)
SOC_DSI_D1N: U1.14 (DSI0_D1N), U6.12 (RXA_D1N)
SOC_DSI_D1P: U1.13 (DSI0_D1P), U6.11 (RXA_D1P)
SOC_DSI_D2N: U1.16 (DSI0_D2N), U6.14 (RXA_D2N)
SOC_DSI_D2P: U1.15 (DSI0_D2P), U6.13 (RXA_D2P)
SOC_DSI_D3N: U1.18 (DSI0_D3N), U6.16 (RXA_D3N)
SOC_DSI_D3P: U1.17 (DSI0_D3P), U6.15 (RXA_D3P)
SOC_PWR_EN: J2.14, U1.74 (PWR_EN), U2.6 (EN), U8.1 (EN), U19.1 (EN)
SOC_RESET_N: J2.13, U1.73 (RESIN_N)
SOC_SPI_CS: J2.10, U1.70 (SPI_MCU_CS)
SOC_SPI_MISO: J2.8, U1.68 (SPI_MCU_MISO)
SOC_SPI_MOSI: J2.9, U1.69 (SPI_MCU_MOSI)
SOC_SPI_SCK: J2.7, U1.67 (SPI_MCU_SCK)
SOC_WAKE_REQ: J2.12, U1.72 (GPIO_WAKE_REQ)
TRKL_CKN: J3.8, U1.20 (CSI0_CKN)
TRKL_CKP: J3.9, U1.19 (CSI0_CKP)
TRKL_D0N: J3.2, U1.22 (CSI0_D0N)
TRKL_D0P: J3.3, U1.21 (CSI0_D0P)
TRKL_D1N: J3.5, U1.24 (CSI0_D1N)
TRKL_D1P: J3.6, U1.23 (CSI0_D1P)
TRKR_CKN: J4.8, U1.26 (CSI1_CKN)
TRKR_CKP: J4.9, U1.25 (CSI1_CKP)
TRKR_D0N: J4.2, U1.28 (CSI1_D0N)
TRKR_D0P: J4.3, U1.27 (CSI1_D0P)
TRKR_D1N: J4.5, U1.30 (CSI1_D1N)
TRKR_D1P: J4.6, U1.29 (CSI1_D1P)
TYPEC_ALT_SEL: U1.92 (TYPEC_ALT_SEL), U11.28 (ALT_SEL)
USB_DM: J1.A7 (D-), J1.B7 (D-), U1.66 (USB_DM), U13.2 (D1-)
USB_DP: J1.A6 (D+), J1.B6 (D+), U1.65 (USB_DP), U13.1 (D1+)
USB_SSRXN: U1.64 (USB3_SSRXN), U11.27 (SSRXN)
USB_SSRXP: U1.63 (USB3_SSRXP), U11.26 (SSRXP)
USB_SSTXN: U1.62 (USB3_SSTXN), U11.25 (SSTXN)
USB_SSTXP: U1.61 (USB3_SSTXP), U11.24 (SSTXP)
USIM_CLK: J12.3 (CLK), U4.18 (USIM1_CLK), U5.3 (CLK)
USIM_DATA: J12.4 (IO), U4.17 (USIM1_DATA), U5.4 (IO)
USIM_DET: J12.5 (DET), U4.15 (USIM1_DET)
USIM_RST: J12.2 (RST), U4.19 (USIM1_RST), U5.2 (RST)
USIM_VDD: C22.1, J12.1 (VCC), U4.16 (USIM1_VDD), U5.1 (VCC)
VBAT_L: C42.1, J13.1, U14.2 (BAT), U14.3 (BAT)
VBUS: C40.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.1, J2.2, U12.1 (VBUS), U14.13 (IN)
VDD_DPU_CORE: C30.1, C31.1, C32.1, L1.2, R1.1, U6.1 (VCC_CORE)
VDD_LT_1V1: C52.1, C53.1, L2.2, R3.1, U10.1 (VDD_1V1)
VDD_SOC_CORE: C1.1, C2.1, U1.1 (VDD_CORE), U2.7 (VREG_CORE)
VDD_SOC_MEM: C4.1, U1.4 (VDD_LPDDR), U2.9 (VREG_MEM)
VDD_SOC_MX: C3.1, U1.2 (VDD_MX), U2.8 (VREG_MX)
VSYS_CELL: C20.1, C21.1, R20.2, U4.63 (VBAT_RF), U4.64 (VBAT_RF), U4.65 (VBAT_BB), U4.66 (VBAT_BB)
VSYS_MAIN: C41.1, J7.18, J7.19, J8.18, J8.19, R20.1, U2.1 (VIN), U2.2 (VIN2), U8.7 (VIN), U14.10 (OUT), U14.11 (OUT), U15.1 (IN), U19.7 (VIN)
WEAR_DET: J2.36
WIFI_PWR_EN: J2.16, U3.18 (PWR_EN), U15.3 (EN)
WLAN_CLKREQ_N: U1.59 (PCIE1_CLKREQ_N), U3.13 (CLKREQ_N)
WLAN_EN: U1.86 (WLAN_EN), U3.15 (WLAN_EN)
WLAN_PCIE_CKN: U1.57 (PCIE1_REFCLKN), U3.11 (PCIE_CKN)
WLAN_PCIE_CKP: U1.56 (PCIE1_REFCLKP), U3.10 (PCIE_CKP)
WLAN_PCIE_RXN: U1.55 (PCIE1_RXN), U3.7 (PCIE_TXN)
WLAN_PCIE_RXP: U1.54 (PCIE1_RXP), U3.6 (PCIE_TXP)
WLAN_PCIE_TXN: U1.53 (PCIE1_TXN), U3.9 (PCIE_RXN)
WLAN_PCIE_TXP: U1.52 (PCIE1_TXP), U3.8 (PCIE_RXP)
WLAN_PERST_N: U1.58 (PCIE1_PERST_N), U3.12 (PERST_N)
WLAN_WAKE_N: U1.60 (PCIE1_WAKE_N), U3.14 (WAKE_N)

Notes on the sheet:
主板（小脑：主 SoC + 显示处理器；脚：RedCap + Wi-Fi 7 + USB-C） · M1 桌面载板形态 100×70 mm，8 层 HDI · 主 SoC / Wi-Fi 7 / FPGA / 开关 为占位：引脚待供应商资料或 NDA；LT7911UXC 已定封装与供电，球位待龙迅规格书 · RedCap 模组 RG255C-GL 已换真实引脚与 LGA-204 焊盘（立创 EDA 公开库），下单前对照移远硬件设计手册核对 · 未布线：只有布局与飞线

Board: 8 copper layers, 100.0 x 70.0 mm, 77 parts (47 on the bottom side), 221 nets, no tracks yet.

## KiCad design hardware/v0.1/kicad/mcu_board/mcu_board.kicad_pcb

Schematic: mcu_board.kicad_sch, MCU 常驻板（小脑常驻 · 脚的 BLE · 耳朵和嘴巴）

Parts:
AE1: 2.4GHz 片状天线; Johanson_2450AT18x100
C1, C11, C55, C63: 10uF; C_0402_1005Metric
C2, C12, C44, C61, C62, C64: 4.7uF; C_0402_1005Metric
C3, C13, C60: 1uF; C_0402_1005Metric
C4, C5, C6, C14, C15, C16, C17, C18, C22, C30, C31, C40, C42, C45, C50, C51, C56, C70: 100nF; C_0201_0603Metric
C21: 2.2uF; C_0201_0603Metric
C23, C24: 8pF; C_0201_0603Metric
C25, C26: 6pF; C_0201_0603Metric
C41, C65: 1uF; C_0201_0603Metric
C43: 47nF; C_0201_0603Metric
C46, C47: 12pF; C_0201_0603Metric
C48: 0.8pF; C_0201_0603Metric
D1: 状态灯; LED_0402_1005Metric
J1: 板间 DF40 40P（至主板）; Hirose_DF40C-40DS-0.4V_2x20_P0.4mm
J2: 右侧电池; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
J3: 扬声器; JST_SH_SM02B-SRSS-TB_1x02-1MP_P1.00mm_Horizontal
J4: SWD（N6 + nRF）; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
L1: 2.2uH; L_0805_2012Metric
L2: 10uH; L_0603_1608Metric
L3: 15nH; L_0402_1005Metric
L4: 3.9nH; L_0201_0603Metric
L5: 0.47uH; L_0805_2012Metric
MK1: PDM 麦克风 L; Knowles_LGA-5_3.5x2.65mm
MK2: PDM 麦克风 R; Knowles_LGA-5_3.5x2.65mm
R1, R22, R23: 10k; R_0201_0603Metric
R2: 4.02k 1%; R_0201_0603Metric
R10: 1.13k; R_0201_0603Metric
R11: 3.0k; R_0201_0603Metric
R12: 46.4k; R_0201_0603Metric
R13: 200k; R_0201_0603Metric
R14: 100k; R_0201_0603Metric
R15: 0; R_0201_0603Metric
R16, R17: 1M; R_0201_0603Metric
R20, R21: 2.2k; R_0201_0603Metric
R24: 1k; R_0201_0603Metric
R25: 0; R_0201_0603Metric; not fitted
SW1: 电源 / 唤醒键; SW_SPST_PTS810
U1: STM32N657X0H3Q; ST_VFBGA-264_14x14mm_P0.8mm
U2: APS6404L 64Mb PSRAM 1.8V; Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm
U3: W25Q128JW 1.8V NOR; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
U4: nRF52832-QFAA; QFN-48-1EP_6x6mm_P0.4mm_EP4.6x4.6mm
U5: MAX98357A; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm
U6: BQ24075; VQFN-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm
U7: TPS62823 1.8V; Texas_VSON-HR-8_1.5x2mm_P0.5mm
U8: TLV75533 3.3V; SOT-23-5
U9: APDS-9160 佩戴检测; Broadcom_APDS-9160-003
Y1: 48MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y2: 32.768kHz; Crystal_SMD_2012-2Pin_2.0x1.2mm
Y3: 32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+1V8: C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C30.1, C31.1, C44.1, C45.1, C50.1, C51.1, C63.1, D1.2 (A), J4.1, L5.2, MK1.5 (VDD), MK2.2 (SEL), MK2.5 (VDD), R13.1, R15.1, U1.A1 (PDR_ON), U1.A4 (VDD33USB), U1.C5 (VDDA18USB), U1.E1 (VBAT), U1.E8 (VDDIO4), U1.E9 (VDDIO5), U1.F6 (VDDA18AON), U1.F8 (VDDIO4), U1.F9 (VDDIO5), U1.G1 (VDDA18PMU), U1.G13 (VDD), U1.H12 (VDD), U1.H13 (VDD), U1.J12 (VDD), U1.J13 (VDD), U1.K1 (VDDSMPS), U1.K2 (VDDSMPS), U1.K3 (VDDSMPS), U1.K4 (VDDSMPS), U1.K5 (VDDSMPS), U1.K6 (VDDSMPS), U1.K13 (VDD), U1.L13 (VDDIO2), U1.L14 (VDDIO2), U1.M5 (VDDA18PLL), U1.M14 (VDDIO2), U1.M15 (VDDIO2), U1.N6 (VDDA18ADC), U1.N13 (VDDIO3), U1.P13 (VDDIO3), U1.R5 (VDDA18CSI), U2.8 (VDD), U3.8 (VCC), U4.13 (VDD), U4.36 (VDD), U4.48 (VDD)
+1V8_AON: J1.5, R15.2, R20.2, R21.2, R22.2, R23.2, U6.5 (EN2)
+3V3: C65.1, C70.1, U8.5 (OUT), U9.5 (LEDA), U9.6 (VDD)
AMP_SD_MODE: U1.R12 (PA7), U5.4 (~SD_MODE)
BAT_NTC: J2.2, U6.1 (TS)
BLE_ANT: L4.1, U4.30 (ANT)
BLE_DCC: L2.1, U4.47 (DCC)
BLE_DCC_L: L2.2, L3.1
BLE_DEC1: C40.1, U4.1 (DEC1)
BLE_DEC2: C42.1, U4.32 (DEC2)
BLE_DEC3: C43.1, U4.33 (DEC3)
BLE_DEC4: C41.1, L3.2, U4.46 (DEC4)
BLE_IRQ: U1.U14 (PA4), U4.14 (P0.11)
BLE_RESET_N: U1.R8 (PA5), U4.24 (P0.21/~RESET)
BLE_RF: AE1.1 (FEED), C48.1, L4.2
BLE_SWCLK: R25.1, U4.25 (SWDCLK)
BLE_SWDIO: J4.6, U4.26 (SWDIO)
BLE_UART_CTS: U1.M2 (PF3), U4.9 (P0.07)
BLE_UART_RTS: U1.M4 (PG5), U4.7 (P0.05/AIN3)
BLE_UART_RX: U1.D14 (PD5), U4.10 (P0.08)
BLE_UART_TX: U1.D9 (PC2), U4.8 (P0.06)
BLE_XC1: C46.1, U4.34 (XC1), Y3.1
BLE_XC2: C47.1, U4.35 (XC2), Y3.3
BTN_PWR: R23.1, SW1.1, U1.R11 (PB1)
BUCK_FB: R13.2, R14.1, U7.2 (FB)
BUCK_SW: L5.1, U7.6 (SW)
CAM_MCU_CKN: J1.26, U1.U3 (CSI_CKN)
CAM_MCU_CKP: J1.25, U1.T3 (CSI_CKP)
CAM_MCU_D0N: J1.29, U1.U5 (CSI_D0N)
CAM_MCU_D0P: J1.28, U1.T5 (CSI_D0P)
CAM_MCU_D1N: J1.32, U1.U4 (CSI_D1N)
CAM_MCU_D1P: J1.31, U1.T4 (CSI_D1P)
CAM_SEL: J1.18, U1.U7 (PA12)
CELL_PWR_EN: J1.15, U1.T8 (PA2)
CHG_ILIM: R10.1, U6.12 (ILIM)
CHG_ISET: R11.1, U6.16 (ISET)
CHG_PGOOD_N: U1.U8 (PA8), U6.7 (~PGOOD)
CHG_STAT_N: U1.P7 (PA9), U6.9 (~CHG)
CHG_TMR: R12.1, U6.14 (TMR)
DISP_LS_CS: J1.22, U1.P9 (PA1)
DISP_LS_DC: J1.23, U1.R7 (PA10)
DISP_LS_MOSI: J1.21, U1.P6 (PG14)
DISP_LS_SCK: J1.20, U1.C8 (PC12)
DISP_SEL: J1.17, U1.T7 (PA11)
FLASH_CLK: U1.P15 (PN6), U3.6 (CLK)
FLASH_CS: U1.R17 (PN1), U3.1 (~CS)
FLASH_IO0: U1.T17 (PN2), U3.5 (DI/IO0)
FLASH_IO1: U1.R15 (PN3), U3.2 (DO/IO1)
FLASH_IO2: U1.N17 (PN4), U3.3 (~WP/IO2)
FLASH_IO3: U1.R16 (PN5), U3.7 (~HOLD/IO3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C30.2, C31.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C50.2, C51.2, C55.2, C56.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C70.2, J1.3, J1.4, J1.6, J1.19, J1.24, J1.27, J1.30, J1.33, J1.39, J1.40, J2.3, J4.5, MK1.2 (SEL), MK1.3 (GND), MK2.3 (GND), R1.2, R2.2, R10.2, R11.2, R12.2, R14.2, R17.2, SW1.2, U1.A17 (VSS), U1.F2 (VSSAPMU), U1.F7 (VSS), U1.F10 (VSS), U1.F11 (VSS), U1.F12 (VSS), U1.G6 (VSSAON), U1.G12 (VSS), U1.H1 (VSSSMPS), U1.H2 (VSSSMPS), U1.H3 (VSSSMPS), U1.H4 (VSSSMPS), U1.H5 (VSSSMPS), U1.H6 (VSSSMPS), U1.K12 (VSS)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
HSE_IN: C23.1, U1.A7 (PH0-OSC_IN(PH0)), Y1.1
HSE_OUT: C24.1, U1.B7 (PH1-OSC_OUT(PH1)), Y1.3
I2C_PWR_SCL: J1.34, R20.1, U1.C11 (PE5), U9.8 (SCL)
I2C_PWR_SDA: J1.35, R21.1, U1.A9 (PC1), U9.7 (SDA)
I2S_BCLK: U1.E17 (PB6), U5.16 (BCLK)
I2S_DOUT: U1.C12 (PD2), U5.1 (DIN)
I2S_LRCLK: U1.E15 (PB0), U5.14 (LRCLK)
LED_K: D1.1 (K), R24.1
LED_STAT: R24.2, U1.U11 (PB10)
LSE_IN: C25.1, U1.D1 (PC14-OSC32_IN(OSC32_IN)), Y2.1
LSE_OUT: C26.1, U1.C1 (PC15-OSC32_OUT(OSC32_OUT)), Y2.2
MCU_IRQ_TO_SOC: J1.11, U1.R13 (PG0)
MIC_PDM_CLK: J1.37, MK1.4 (CLOCK), MK2.4 (CLOCK), U1.F15 (PE2)
MIC_PDM_DAT: J1.38, MK1.1 (DATA), MK2.1 (DATA), U1.A15 (PE8)
N6_BOOT0: R1.1, U1.G4 (BOOT0)
N6_CSI_REXT: R2.1, U1.P5 (CSI_REXT)
N6_NRST: C22.1, J4.3, U1.G3 (NRST)
N6_SMPS_LX: L1.1, U1.J1 (VLXSMPS), U1.J2 (VLXSMPS), U1.J3 (VLXSMPS), U1.J4 (VLXSMPS), U1.J5 (VLXSMPS), U1.J6 (VLXSMPS)
N6_SWCLK: J4.4, R25.2, U1.T6 (PA14(JTCK/SWCLK))
N6_SWDIO: J4.2, U1.U6 (PA13(JTMS/SWDIO))
N6_V08CAP: C21.1, U1.F1 (V08CAP)
PROX_LDR: U9.3 (LDR), U9.4 (LEDK)
PSRAM_CLK: U1.N16 (PO4), U2.6 (SCLK)
PSRAM_CS: U1.M17 (PO0), U2.1 (~CE)
PSRAM_IO0: U1.G17 (PP0), U2.5 (SI/SIO0)
PSRAM_IO1: U1.H16 (PP1), U2.2 (SO/SIO1)
PSRAM_IO2: U1.J17 (PP2), U2.3 (SIO2)
PSRAM_IO3: U1.J16 (PP3), U2.7 (SIO3)
SOC_PWR_EN: J1.14, U1.U13 (PG11)
SOC_RESET_N: J1.13, U1.T10 (PG10)
SOC_SPI_CS: J1.10, U1.B2 (PH6)
SOC_SPI_MISO: J1.8, U1.B15 (PD4)
SOC_SPI_MOSI: J1.9, U1.D2 (PH7)
SOC_SPI_SCK: J1.7, U1.A12 (PE15)
SOC_WAKE_REQ: J1.12, U1.R9 (PG1)
SPK_N: J3.2, U5.10 (OUTN)
SPK_P: J3.1, U5.9 (OUTP)
VBAT: C62.1, J2.1, R16.1, U6.2 (BAT), U6.3 (BAT)
VBAT_SENSE: R16.2, R17.1, U1.U10 (PA0)
VBUS: C60.1, J1.1, J1.2, U6.13 (IN)
VCORE_0V8: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, L1.2, U1.G2 (VFBSMPS), U1.L6 (VDDCORE), U1.L12 (VDDCORE), U1.M7 (VDDCORE), U1.M9 (VDDCORE), U1.M11 (VDDCORE), U1.N8 (VDDCORE), U1.N10 (VDDCORE), U1.N12 (VDDCORE), U1.P11 (VDDCORE), U1.R4 (VDDCSI)
VSYS: C55.1, C56.1, C61.1, C64.1, U5.7 (VDD), U5.8 (VDD), U6.10 (OUT), U6.11 (OUT), U7.1 (EN), U7.7 (VIN), U8.1 (IN), U8.3 (EN)
WEAR_DET: J1.36, R22.1, U1.P8 (PA6), U9.2 (INT)
WIFI_PWR_EN: J1.16, U1.R14 (PA3)

Notes on the sheet:
MCU 常驻板（小脑常驻 · 脚的 BLE · 耳朵和嘴巴） · 右镜腿形 78×16 mm，6 层，双面贴装 · MCU A 案：STM32N657 + nRF52832（常驻 BLE） · 去耦电容为初版代表值，须按各芯片手册补全 · 未布线：只有布局与飞线

Board: 6 copper layers, 78.0 x 16.0 mm, 84 parts (63 on the bottom side), 95 nets.

## Code that names these connections

File hardware/v0.1/generator/design.py (part):

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    for name, (net, s) in A.used.items():
        nets[N6[name][0]] = net
    # 时钟、调试
    nets[N6['PH0-OSC_IN(PH0)'][0]] = 'HSE_IN'; nets[N6['PH1-OSC_OUT(PH1)'][0]] = 'HSE_OUT'
    nets[N6['PC14-OSC32_IN(OSC32_IN)'][0]] = 'LSE_IN'; nets[N6['PC15-OSC32_OUT(OSC32_OUT)'][0]] = 'LSE_OUT'
    nets[N6['PA13(JTMS/SWDIO)'][0]] = 'N6_SWDIO'; nets[N6['PA14(JTCK/SWCLK)'][0]] = 'N6_SWCLK'
    for nm, net in [('CSI_CKP', 'CAM_MCU_CKP'), ('CSI_CKN', 'CAM_MCU_CKN'), ('CSI_D0P', 'CAM_MCU_D0P'), ('CSI_D0N', 'CAM_MCU_D0N'), ('CSI_D1P', 'CAM_MCU_D1P'), ('CSI_D1N', 'CAM_MCU_D1N')]:
        nets[N6[nm][0]] = net
    b.add('U1', 'STM32N657X0H3Q', 'glasses:ST_VFBGA-264_14x14mm_P0.8mm', 'STM32N657X0H3Q', nets,
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    b.R('R1', '10k', 'N6_BOOT0', 'GND', side='B', group='mcu')
    b.C('C22', '100nF', 'N6_NRST', 'GND', side='B', group='mcu')
    b.R('R2', '4.02k 1%', 'N6_CSI_REXT', 'GND', side='B', group='mcu', note='CSI 参考电阻，阻值待核')
    b.add('Y1', 'Crystal_GND24', 'Crystal:Crystal_SMD_2016-4Pin_2.0x1.6mm', '48MHz', {'1': 'HSE_IN', '3': 'HSE_OUT', '2': 'GND', '4': 'GND'}, side='B', group='mcu')
    b.C('C23', '8pF', 'HSE_IN', 'GND', side='B', group='mcu'); b.C('C24', '8pF', 'HSE_OUT', 'GND', side='B', group='mcu')
    b.add('Y2', 'Crystal', 'Crystal:Crystal_SMD_2012-2Pin_2.0x1.2mm', '32.768kHz', {'1': 'LSE_IN', '2': 'LSE_OUT'}, side='B', group='mcu')
    b.C('C25', '6pF', 'LSE_IN', 'GND', side='B', group='mcu'); b.C('C26', '6pF', 'LSE_OUT', 'GND', side='B', group='mcu')
    # 外部存储
    b.add('U2', 'APS6404L-SQRx-ZR', 'Package_SON:Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm', 'APS6404L 64Mb PSRAM 1.8V',
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    b.L('L2', '10uH', 'BLE_DCC', 'BLE_DCC_L', fp='Inductor_SMD:L_0603_1608Metric', side='B', group='ble')
    b.L('L3', '15nH', 'BLE_DCC_L', 'BLE_DEC4', fp='Inductor_SMD:L_0402_1005Metric', side='B', group='ble')
    b.C('C44', '4.7uF', '+1V8', 'GND', size='0402', side='B', group='ble'); b.C('C45', '100nF', '+1V8', 'GND', side='B', group='ble')
    b.add('Y3', 'Crystal_GND24', 'Crystal:Crystal_SMD_2016-4Pin_2.0x1.6mm', '32MHz', {'1': 'BLE_XC1', '3': 'BLE_XC2', '2': 'GND', '4': 'GND'}, pos=(63.5, 4), group='ble')
    b.C('C46', '12pF', 'BLE_XC1', 'GND', group='ble'); b.C('C47', '12pF', 'BLE_XC2', 'GND', group='ble')
    b.L('L4', '3.9nH', 'BLE_ANT', 'BLE_RF', fp='Inductor_SMD:L_0201_0603Metric', group='ble')
    b.C('C48', '0.8pF', 'BLE_RF', 'GND', group='ble', note='π 型匹配，数值按 Nordic 参考设计待调')
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    soc += [('USB3_SSTXP', 'USB_SSTXP', 'output'), ('USB3_SSTXN', 'USB_SSTXN', 'output'), ('USB3_SSRXP', 'USB_SSRXP', 'input'), ('USB3_SSRXN', 'USB_SSRXN', 'input'),
            ('USB_DP', 'USB_DP', 'bidirectional'), ('USB_DM', 'USB_DM', 'bidirectional'),
            ('SPI_MCU_SCK', 'SOC_SPI_SCK', 'output'), ('SPI_MCU_MISO', 'SOC_SPI_MISO', 'input'), ('SPI_MCU_MOSI', 'SOC_SPI_MOSI', 'output'), ('SPI_MCU_CS', 'SOC_SPI_CS', 'output'),
            ('GPIO_MCU_IRQ', 'MCU_IRQ_TO_SOC', 'input'), ('GPIO_WAKE_REQ', 'SOC_WAKE_REQ', 'input'), ('RESIN_N', 'SOC_RESET_N', 'input'), ('PWR_EN', 'SOC_PWR_EN', 'input'),
            ('SPI_DPU_SCK', 'DPU_SPI_SCK', 'output'), ('SPI_DPU_MOSI', 'DPU_SPI_MOSI', 'output'), ('SPI_DPU_MISO', 'DPU_SPI_MISO', 'input'), ('SPI_DPU_CS', 'DPU_SPI_CS', 'output'),
            ('I2C_SNS_SCL', 'I2C_SNS_SCL', 'output'), ('I2C_SNS_SDA', 'I2C_SNS_SDA', 'bidirectional'), ('IMU_INT', 'IMU_INT1', 'input'),
            ('PDM_CLK', 'MIC_PDM_CLK', 'input'), ('PDM_DAT', 'MIC_PDM_DAT', 'input'),
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                note='A1 有线原始画面入口。已按龙迅产品简介改为 BGA169 9×9 mm、3.3 V + 1.1 V 供电、25 MHz 晶振；'
                     '芯片内置双 CC 与 PD 控制器，U12 PD 控制器有望省掉（待定）；球位编号要龙迅完整规格书')
    # LT7911UXC 外围：25 MHz 晶振（±50 ppm）与 1.1 V 内核降压
    b.add('Y1', 'Crystal_GND24', 'Crystal:Crystal_SMD_2016-4Pin_2.0x1.6mm', '25MHz ±50ppm', {'1': 'LT_XI', '3': 'LT_XO', '2': 'GND', '4': 'GND'}, side='B', group='dp')
    b.C('C50', '12pF', 'LT_XI', 'GND', side='B', group='dp'); b.C('C51', '12pF', 'LT_XO', 'GND', side='B', group='dp', note='负载电容按所选晶振规格调整')
    b.add('U19', 'TPS62823DLC', 'Package_SON:Texas_VSON-HR-8_1.5x2mm_P0.5mm', 'TPS62823 LT7911UXC 1.1V',
          {'EN': 'SOC_PWR_EN', 'FB': 'LT_FB', 'AGND': 'GND', 'PGND': 'GND', 'SW': 'LT_SW', 'VIN': 'VSYS_MAIN', 'PG': None}, side='B', group='dp',
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